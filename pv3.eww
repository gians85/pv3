<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\pv3.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>